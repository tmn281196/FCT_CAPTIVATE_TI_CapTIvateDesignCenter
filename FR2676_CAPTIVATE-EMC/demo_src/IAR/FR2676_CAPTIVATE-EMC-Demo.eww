<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FR2676_CAPTIVATE-EMC-Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
