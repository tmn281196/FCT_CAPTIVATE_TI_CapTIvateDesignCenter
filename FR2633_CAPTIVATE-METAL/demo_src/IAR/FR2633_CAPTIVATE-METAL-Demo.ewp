# IAR project FR2633_CAPTIVATE-METAL-Demo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xssfn.h
  General.OGChipSelectMenu: MSP430FR2633 MSP430FR2633
  General.GStackSize2: 256
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: TARGET_IS_MSP430FR2633; TARGET_IS_MSP430FR2XX_4XX
  ICC430.newCCIncludePaths: ../; ../captivate; ../captivate/ADVANCED; ../captivate/BASE; ../captivate/COMM; ../captivate_app; ../captivate_config; ../driverlib/MSP430FR2xx_4xx; ../driverlib; ../I2CMaster; ../FourDigitDisplay; ../demo
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr2633.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ../; ../captivate; ../captivate/ADVANCED; ../captivate/BASE; ../captivate/COMM; ../captivate_app; ../captivate_config; ../driverlib/MSP430FR2xx_4xx
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c
  group captivate
    ../captivate/: captivate.h
  group captivate/ADVANCED
    ../captivate/ADVANCED/: CAPT_Buttons.h CAPT_EMC.h CAPT_Manager.c CAPT_Manager.h CAPT_Slider.h
  group captivate/BASE
    ../captivate/BASE/: CAPT_HAL.h CAPT_ISR.c CAPT_Touch.h CAPT_Type.h rom_captivate.h rom_map_captivate.h
  group captivate/BASE/libraries
    ../captivate/BASE/libraries/: captivate_fr2633_family.r43
  group captivate/BASE/rom_headers
    ../captivate/BASE/rom_headers/: rom_captivate_msp430fr2633_family.h
  group captivate/COMM
    ../captivate/COMM/: CAPT_ByteQueue.h CAPT_CommConfig.h CAPT_Interface.c CAPT_Interface.h CAPT_PingPongBuffer.h CAPT_Protocol.h FunctionTimer.c FunctionTimer.h FunctionTimer_Definitions.h I2CSlave.c I2CSlave.h I2CSlave_Definitions.h UART.c UART.h UART_Definitions.h
  group captivate_app
    ../captivate_app/: CAPT_App.c CAPT_App.h CAPT_BSP.c CAPT_BSP.h
  group captivate_config
    ../captivate_config/: CAPT_UserConfig.c CAPT_UserConfig.h
  group demo
    ../demo/: CAPTIVATE_METAL_Demo.c CAPTIVATE_METAL_Demo.h
  group driverlib/MSP430FR2xx_4xx
    ../driverlib/MSP430FR2xx_4xx/: adc.h crc.h cs.h driverlib.h eusci_a_spi.h eusci_a_uart.h eusci_b_i2c.h eusci_b_spi.h framctl.h gpio.h lcd_e.h pmm.h rom_driverlib.h rom_map_driverlib.h rtc.h sfr.h sysctl.h timer_a.h tlv.h wdt_a.h
  group driverlib/MSP430FR2xx_4xx/deprecated/CCS
    ../driverlib/MSP430FR2xx_4xx/deprecated/CCS/: msp430fr2xx_4xxgeneric.h
  group driverlib/MSP430FR2xx_4xx/deprecated/IAR
    ../driverlib/MSP430FR2xx_4xx/deprecated/IAR/: msp430fr2xx_4xxgeneric.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h hw_regaccess.h version.h
  group driverlib/MSP430FR2xx_4xx/libraries
    ../driverlib/MSP430FR2xx_4xx/libraries/: driverlib_fr2633_family.r43
  group FourDigitDisplay
    ../FourDigitDisplay/: FourDigitDisplay.c FourDigitDisplay.h TCA95xx.c TCA95xx.h
  group I2CMaster
    ../I2CMaster/: I2CMaster.c I2CMaster.h I2CMaster_Definitions.h
