<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
   <path>$WS_DIR$/8TX4X_BTN0001.ewp</path>
  </project>
  <batchBuild/>
</workspace>


