<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
   <path>$WS_DIR$/8TX4RX_BTN01.ewp</path>
  </project>
  <batchBuild/>
</workspace>


