<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FR2676_CAPTIVATE-METAL-Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


