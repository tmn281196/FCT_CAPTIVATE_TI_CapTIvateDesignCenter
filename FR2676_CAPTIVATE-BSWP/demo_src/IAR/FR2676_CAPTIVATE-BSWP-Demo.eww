<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
   <path>$WS_DIR$/FR2676_CAPTIVATE-BSWP-Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


